## config/boards/shields/xiao_ble_remote/Kconfig.shield
```kconfig
config SHIELD_XIAO_BLE_REMOTE
    def_bool $(shields_list_contains,xiao_ble_remote)
```
